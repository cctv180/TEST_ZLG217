# Keil uVision project project.uvprojx, settings and files
target debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ZLG217 Generic
  pack: ZLG.ZLG200_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M3
  c include: ..\user_code;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\ametal\3rdparty\CMSIS\Include;..\ametal\arch\arm\include;..\ametal\board\bsp_common\include;..\ametal\components\drivers\include;..\ametal\components\service\include;..\ametal\components\util\include;..\examples\board\am217_core;..\ametal\examples\components;..\ametal\examples\soc\zlg;..\ametal\examples\std;..\ametal\interface;..\ametal\soc\zlg\zlg217;..\ametal\soc\zlg\drivers\include\adc;..\ametal\soc\zlg\drivers\include\bkp;..\ametal\soc\zlg\drivers\include\bkp\hw;..\ametal\soc\zlg\drivers\include\clk;..\ametal\soc\zlg\drivers\include\cmp;..\ametal\soc\zlg\drivers\include\crc;..\ametal\soc\zlg\drivers\include\dac;..\ametal\soc\zlg\drivers\include\dma;..\ametal\soc\zlg\drivers\include\exti;..\ametal\soc\zlg\drivers\include\flash\hw;..\ametal\soc\zlg\drivers\include\gpio;..\ametal\soc\zlg\drivers\include\i2c;..\ametal\soc\zlg\drivers\include\pwr;..\ametal\soc\zlg\drivers\include\rcc;..\ametal\soc\zlg\drivers\include\spi;..\ametal\soc\zlg\drivers\include\syscfg\hw;..\ametal\soc\zlg\drivers\include\tim;..\ametal\soc\zlg\drivers\include\uart;..\ametal\soc\zlg\drivers\include\wdt;..\ametal\board\bsp_common\include;..\user_config;..\ametal\soc\zlg\drivers\include\gpio\hw;..\ametal\soc\zlg\drivers\include\pwr\hw;..\ametal\soc\zlg\drivers\include\rtc\hw;..\ametal\soc\zlg\drivers\include\afio\hw;..\ametal\soc\zlg\drivers\include\rcc\hw;..\ametal\soc\zlg\drivers\include\exti\hw;..\ametal\soc\zlg\drivers\include\adc;..\ametal\soc\zlg\drivers\include\adc\hw;..\ametal\soc\zlg\drivers\include\uart\hw;..\ametal\soc\zlg\drivers\include\flash;..\ametal\soc\zlg\drivers\include\crc\hw;..\ametal\soc\zlg\drivers\include\dac\hw;..\ametal\soc\zlg\drivers\include\dma\hw;..\ametal\soc\zlg\drivers\include\i2c\hw;..\ametal\soc\zlg\drivers\include\wdt\hw;..\ametal\soc\zlg\drivers\include\spi\hw;..\ametal\soc\zlg\drivers\include\tim\hw;..\ametal\arch\arm\include\hw;..\ametal\soc\zlg\drivers\include\rtc;..\ametal\examples\components;..\ametal\components\libc\newlib_adapter\include;..\ametal\soc\zlg\drivers\include\ili9341;..\ametal\components\libc\armlib_adapter\include;..\ametal\components\libc\microlib_adapter\include;..\ametal\components\libc\newlib_adapter\include;..\ametal\soc\zlg\drivers\include\can;..\ametal\soc\zlg\drivers\include\can\hw;..\ametal\soc\zlg\drivers\include\usbd;..\ametal\soc\zlg\drivers\include\usbd\hw;..\ametal\components\usb\device;..\ametal\components\usb\include;..\ametal\components\usb\osa;..\ametal\components\usb\host\config;..\ametal\components\usb\host\common\include;..\ametal\components\usb\host\class\include;..\ametal\components\usb\device\config\include;..\ametal\components\usb\host;..\ametal\soc\zlg\drivers\include\syscfg;..\ametal\components\drivers\source\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group bsp_common
    ../ametal/board/bsp_common/source/: am_bsp_armlib.c am_bsp_microlib.c am_bsp_delay_timer.c am_bsp_system_heap.c am_bsp_isr_defer_pendsv.c
  group arm
    ../ametal/arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../ametal/components/drivers/source/adc/: am_cs1237.c
    ../ametal/components/drivers/source/ble/: am_zlg9021.c
    ../ametal/components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../ametal/components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../ametal/components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../ametal/components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../ametal/components/drivers/source/digitron_key/: am_zlg72128_std.c zlg72128.c zlg72128_platform.c
    ../ametal/components/drivers/source/fingerprint/: am_ts10x.c
    ../ametal/components/drivers/source/flash/: am_mx25xx.c
    ../ametal/components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../ametal/components/drivers/source/i2c/: am_i2c_gpio.c
    ../ametal/components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../ametal/components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../ametal/components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../ametal/components/drivers/source/nvram/: am_ep24cxx.c
    ../ametal/components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
    ../ametal/components/drivers/source/sht20/: am_sht20.c
    ../ametal/components/drivers/source/spi/: am_spi_gpio.c
    ../ametal/components/drivers/source/temperature/: am_temp_lm75.c
    ../ametal/components/drivers/source/uart/: am_sc16is7xx.c
    ../ametal/components/drivers/source/zigbee/: am_zm516x.c
    ../ametal/components/drivers/source/zlg600/: am_zlg600.c
    ../ametal/components/drivers/source/lcd/: am_ili9341.c am_ili9341_intfc_3wire.c
  group libc
    ../ametal/components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../ametal/components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../ametal/components/service/source/: am_adc.c am_buzzer_dev.c am_event_category_input.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_timer.c am_uart.c am_uart_rngbuf.c
  group util
    ../ametal/components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../ametal/soc/zlg/drivers/source/adc/: am_zlg_adc.c
    ../ametal/soc/zlg/drivers/source/crc/: am_zlg_crc.c
    ../ametal/soc/zlg/drivers/source/dac/: am_zlg_dac.c
    ../ametal/soc/zlg/drivers/source/dma/: am_zlg_dma.c
    ../ametal/soc/zlg/drivers/source/flash/: am_zlg_flash.c
    ../ametal/soc/zlg/drivers/source/i2c/: am_zlg_i2c.c am_zlg_i2c_slv.c
    ../ametal/soc/zlg/drivers/source/spi/: am_zlg_spi_dma.c am_zlg_spi_int.c am_zlg_spi_slv_dma.c am_zlg_spi_poll.c
    ../ametal/soc/zlg/drivers/source/tim/: am_zlg_tim_cap.c am_zlg_tim_pwm.c am_zlg_tim_timing.c
    ../ametal/soc/zlg/drivers/source/uart/: am_zlg_uart.c
    ../ametal/soc/zlg/drivers/source/uart/hw/: amhw_zlg_uart.c
    ../ametal/soc/zlg/drivers/source/wdt/: am_zlg_iwdg.c am_zlg_wwdg.c
    ../ametal/soc/zlg/drivers/source/rcc/hw/: amhw_zlg217_rcc.c
    ../ametal/soc/zlg/drivers/source/gpio/: am_zlg217_gpio.c
    ../ametal/soc/zlg/drivers/source/pwr/: am_zlg217_pwr.c
    ../ametal/soc/zlg/drivers/source/clk/: am_zlg217_clk.c
    ../ametal/soc/zlg/drivers/source/ili9341/: am_zlg_ili9341_3wire_spi.c
    ../ametal/soc/zlg/drivers/source/rtc/: am_zlg217_rtc.c
  group startup
    ../startup/: am_zlg217_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/: am_prj_config.c am_board.c am_zlg217_inst_init.h am_prj_config.h am_board.h
    ../user_config/am_hwconf_usrcfg/: am_hwconf_arm_nvic.c am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_key_gpio.c am_hwconf_lcd_ili9341.c am_hwconf_led_gpio.c am_hwconf_lm75.c am_hwconf_microport_ds1302.c am_hwconf_microport_eeprom.c am_hwconf_microport_flash.c am_hwconf_microport_rs485.c am_hwconf_microport_rtc.c am_hwconf_microport_rx8025t.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_system_tick_softimer.c am_hwconf_zlg217_adc.c am_hwconf_zlg217_clk.c am_hwconf_zlg217_crc.c am_hwconf_zlg217_dac.c am_hwconf_zlg217_dma.c am_hwconf_zlg217_gpio.c am_hwconf_zlg217_i2c.c am_hwconf_zlg217_i2c_slv.c am_hwconf_zlg217_iwdg.c am_hwconf_zlg217_pwr.c am_hwconf_zlg217_rtc.c am_hwconf_zlg217_spi_dma.c am_hwconf_zlg217_spi_int.c am_hwconf_zlg217_systick.c am_hwconf_zlg217_tim_cap.c am_hwconf_zlg217_tim_pwm.c am_hwconf_zlg217_tim_timing.c am_hwconf_zlg217_uart.c am_hwconf_zlg217_wwdg.c
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c
